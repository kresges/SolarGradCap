# Repository kresges/SolarGradCap

## EAGLE design Board Files/SGC.0.brd

Parts:
C1, C18, C19, C20, C21: 1.0uF; C0603
C2: 10uF; 1210
C3, C4: 47uF; EIA3528
C5: 10uF; 1206
C6: 1.0uF; 0603-CAP
C8, C12, C13: 0.1uF; C0603; MPN 0603YC104KAZ2A
C9, C11: 15pF; C0603; MPN 0201ZC103KAT2A
C10: 1uF; C0603; MPN C0603C302J5GACTU
C16, C17: 4.7uF; C0603
D1, D2: ZLLS500; SOT23
D3, D4, D5: RED; LED-0603
IC1: AT90USB1287-AU; TQFP64
J1: POWER_JACKPTH_LOCK; POWER_JACK_PTH_LOCK
JP1, JP2, JP5: M02PTH; 1X02
JP3: JUMPER-PTH-2-NC; PTH-JUMPER-NC_BOTTOM_NO_SILK
JP4: R_SEN; 1X02
JP7: M10LOCK; 1X10_LOCK
L1: 68uH; CR75
R1, R3, R35, R36: 47K; R0603
R2: 0.22; 0805
R4, R6: 220k; 0603-RES
R5: 47k; 0603-RES
R7: TRIMPOT; TRIMPOT-5MM-V2
R8: 2.5K; R0603
R9: 330; R0603
R10, R11: 4.7K; R0603
R37, R38: 22; R0603; MPN CRCW06034K70FKEA
R39, R40: 330; R0603; MPN CR0603FX3300ELF
U1: MCP73831; SOT23-5
U2: LT3652; MSOP-12_GND
U$1, U$5, U$8: USB_MICRO_B_DX4
U$2, U$4: TPS73633-EP; SOT23-5
U$3: TPS61030PWPR; TSSOP16
U$6: RN4020
U$7: SWITCH_SLIDE
X1: CRYSTALCTS406; CTS406

Connections:
3.3V: C12.1, C13.1, C19.1, C21.1, IC1.21 (VCC), IC1.52 (VCC), JP7.1, R10.2, R11.2, R35.1, R36.2, U$2.5, U$4.5, U$6.23 (VDD)
!CHRG: U2.4 (!CHRG)
!FAULT: U2.5 (!FAULT)
A6: IC1.45 (PA6(AD6)), R39.2
A7: IC1.44 (PA7(AD7)), R40.2
BATTSIG: IC1.61 (PF0(ADC0)), R1.1, R3.2
BOOST: C6.1, D2.3 (C), U2.11 (BOOST)
BT_CMD: IC1.51 (PA0(AD0)), U$6.8 (CMD/MLDP)
BT_UART_RX: IC1.28 (PD3(TXD1/INT3)), U$6.6 (UART_RX)
BT_UART_TX: IC1.27 (PD2(RXD1/INT2)), U$6.5 (UART_TX)
D+: IC1.5 (D+), R37.1
D-: IC1.4 (D-), R38.1
FAN: IC1.50 (PA1(AD1)), JP7.3
FB: R4.2, R5.1, R6.2
GND: C1.2, C2.2, C3.C (-), C4.C (-), C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D1.1 (A), D4.C, D5.C, IC1.6 (UGND), IC1.22 (GND), IC1.53 (GND), IC1.63 (GND), J1.GND, J1.GNDBREAK, JP1.1, JP2.2, JP5.2, JP7.2, R3.1, R4.1, R7.C (CW), R8.1, U1.2 (VSS), U2.6 (TIMER), U2.13 (GND_PAD), U$1.GND (4), U$2.2, U$2.4, U$4.2, U$4.4, U$5.GND (4), U$6.1 (GND0), U$6.9 (GND1), U$6.16 (GND2), U$6.24 (GND3)
HWB: IC1.43 (PE2(ALE/HWB)), JP5.1, R36.1
ID: U$1.ID
LBI: U$3.7 (LBI)
MISO: IC1.13 (PB3(PDO/PCINT3/MISO)), JP7.4
MOSI: IC1.12 (PB2(PDI/PCINT2/MOSI)), JP7.5
unnamed: R37.2, U$1.D+ (3)
unnamed: R38.2, U$1.D- (2)
unnamed: C10.1, IC1.7 (UCAP)
unnamed: R6.1, U2.7 (VFB)
unnamed: C3.A (+), C4.A (+), C5.1, D2.1 (A), JP3.1, JP4.1, R2.2, R5.2, U2.9 (BAT)
unnamed: C8.1, IC1.62 (AREF)
unnamed: D3.A, R9.1
unnamed: D3.C, U1.1 (STAT)
unnamed: R8.2, U1.5 (PROG)
unnamed: D4.A, R39.1
unnamed: D5.A, R40.1
NTC: U2.8 (NTC)
RESET: IC1.20 (RESET), JP2.1, R35.2
SCK: IC1.11 (PB1(PCINT1/SCK)), JP7.6
SCL: IC1.25 (PD0(OC.0B/SCL/INT0)), JP7.9, R11.1
SDA: IC1.26 (PD1(OC.2B/SDA/INT1)), JP7.8, R10.1
SENSE: JP4.2, L1.P$2 (2), R2.1, U2.10 (SENSE)
SET: R7.B (WIPER), U2.2 (VIN_REG)
SOLAR_IN: C2.1, J1.PWR, R7.A (CCW), U2.1 (VIN), U2.3 (!SHDN)
SS: IC1.10 (PB0(SS/PCINT0)), JP7.7
SW: C6.2, D1.3 (C), L1.P$1 (1), U2.12 (SW)
UVCC: IC1.3 (UVCC)
VBAT: JP3.2, U$3.6 (VBAT)
VBAT_IN: C1.1, C17.1, JP1.2, R1.2, U1.3 (VBAT), U$7.3
VBAT_OUT: C20.1, U$4.1, U$4.3, U$7.1
VBUS: C16.1, C18.1, IC1.8 (VBUS), R9.2, U1.4 (VIN), U$1.VBUS (1), U$2.1, U$2.3, U$5.VBUS (1)
XTAL1: C11.1, IC1.23 (XTAL2), X1.1
XTAL2: C9.1, IC1.24 (XTAL1), X1.3 (2)

Notes on the sheet:
RESET
BOOTLOADER ACTIVATION
MICROCONTROLLER
8MHZ CRYSTAL
BATTERY INPUT
Cut the JP3 trace to measure output current. Adjust trim pot until output current reaches its maximum.
R_SEN is in parallel with R1. Small resistors can be added to increase the charge current from the default ~450mA.
0.22 -> 800mA
Ichg = .1/(R1||Rsen)
Typical R_SEN values vs. Ichg
1.0 -> 550mA
0.33 -> 750mA
0.5 -> 650mA
SOLAR CHARGER
3.3V SYSTEM VOLTAGE
NOTE: IREG = 1000v / RPROG
NOTE: IREG is set for 400mA charge current
USB BATTERY CHARGER
FLASH UTILITY
BLUETOOTH

Board: 2 copper layers, 60 parts (14 on the bottom side), 42 nets, no tracks yet.

## EAGLE design Board Files/Power Supplies/3.3V SYSTEM/Eagle/2015-11-14_13-10-41/2015-11-14_13-10-41.brd

File Board Files/Power Supplies/3.3V SYSTEM/Eagle/2015-11-14_13-10-41/readme.txt:

**********************************************************
*****************Schematic Instructions  *******************
**********************************************************

To import your new Schematic file into Eagle:

1. Unzip the downloaded folder files to local directory and Start Eagle.
2. Select "File"->"Open"->"Schematic..." from the menu at the top of
   the screen.
3. Browse to your newly exported file and select the ".sch" file extension.
4. You should now see your schamtic available in Eagle.

**********************************************************
*******************  PCB Instructions  *******************
**********************************************************

To import your new BOARD file into Eagle:

1. Unzip the downloaded folder files to local directory and Start Eagle.
2. Select "File"->"Open"->"Board..." from the menu at the top of
   the screen.
3. Browse to your newly exported file and select the ".brd" file extension.
4. Planes will need to be repoured to update the polygon fills
	1. Once your board is loaded, type "ratsnest" into the command
	   line and press the Enter key.
	2. The polygons should all be filled now.
5. You should now have an image of your board available in Eagle.

**********************************************************
*******************  LIB Instructions  *******************
**********************************************************

To import your new library into Eagle:

1. Start Eagle.
2. Select "File"->"New"->"Library" from the menu.
3. In the blank library window, select "File" -> "Execute Script"
   from the menu.
5. Browse to your newly exported Eagle Script file (".scr" file extension)
6. After opening the file, the script will populate the new library.
   Layer 93 should NOT exist.
7. Use "File"->"Save" (or "Save As..") to save the library to the desired
   location in Eagle native format.

For additional information, please visit this site:
http://www.accelerated-designs.com/help/Eagle_import.html

You may also find this video helpful:
http://youtu.be/5jGuWY-Yy3Q

**********************************************************
**********************************************************
**********************************************************

Board: 4 copper layers, 10 parts (0 on the bottom side), 7 nets.

Parts:
Cin: 1206_190
Cout: 1206_190
CvinA: 0805
GND, GND1: TP-1502
L1: MLP2520K-M
Rpg: 0805
U1: R-PVSON-N14
Vin: TP-1502
Vout: TP-1502

Connections:
0: Cin.2, Cout.2, CvinA.2, U1.2, U1.13, U1.15
1: Cout.1, Rpg.1, U1.3, U1.4, U1.5, Vout.1
2: L1.2, U1.8, U1.9
3: CvinA.1, GND.1, GND1.1, U1.1, U1.12
4: Cin.1, U1.10, U1.11, Vin.1
5: L1.1, U1.6, U1.7
12: Rpg.2, U1.14

## EAGLE design Board Files/Power Supplies/3.3V SYSTEM/Eagle/2015-11-14_12-31-03/2015-11-14_12-31-03.brd

Board: 2 copper layers, 100.0 x 80.0 mm, 8 parts (0 on the bottom side), 6 nets, no tracks yet.

Parts:
CIN: 22uF; 1206_190
COUT: 47uF; 1206_190
CVINA: 100nF; 0805
GND: WB_GND
IOUT: WB_CURRENT_LOAD
L1: 1uH; MLP2520K-S
U1: TPS63021DSJR; R-PVSON-N14
VIN: WB_BATTERY

Connections:
0: CIN.2, COUT.2, CVINA.2, GND.1, IOUT.2, U1.2, U1.13, U1.15, VIN.2
1: COUT.1, IOUT.1, U1.3, U1.4, U1.5
2: L1.2, U1.8, U1.9
3: CVINA.1, U1.1, U1.12
4: CIN.1, U1.10, U1.11, VIN.1
5: L1.1, U1.6, U1.7

## Commit log

2015-10-28 Create Board Files
    Creation of schematic and board file. Only the AT90USB1287-AU has been
    added.
2015-10-28 Board File Folder
2015-10-28 Revert "Board File Folder"
    This reverts commit 4800c40f4791f2b92b441bfa53057afc271b956f.
2015-10-28 Create Folders
2015-10-29 Microcontroller block update
2015-11-03 Block Diagram Update
2015-11-15 Update Power Supplies and Library
2015-11-16 UI Elements
    Buttons, Colors, SQUAD
2016-02-18 Midterm Checkoff
2016-03-11 Embedded Code
    Code to run on the Teensy
2016-03-11 Android Application
    Android application code
2016-04-14 LED change
    updated # of led's to turn on
2016-04-23 no LED button added
    Added a button to turn off LED's
2016-04-23 Update LED Off code
    Still need to test this hardware wise
2016-05-02 LED Off Fix
    Fixed code to turn LED's on and off
2016-05-20 Changed LED Patterns
    Changed patterns of the LED's to go all around the cap

Notices in the files:
parts and their libraries:
SparkFun-Electromechanical: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Resistors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
